FILESEXTRAPATHS:prepend:stm32mp15-disco := "${THISDIR}/${PN}:"
